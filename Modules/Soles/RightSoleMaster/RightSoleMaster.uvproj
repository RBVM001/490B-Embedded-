# Keil uVision project RightSoleMaster.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: TM4C1233H6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: RightSoleMaster
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: init.c main.c Init.h tm4c123gh6pm.h Sender.c startup.s Sender.h PLL.h PLL.c diskio.c ff.c Storage.c diskio.h ff.h ffconf.h integer.h Storage.h Master.c
