# Keil uVision project LeftSoleSlave.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: LeftSoleSlave
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: diskio.c ff.c init.c main.c PLL.c Storage.c startup.s diskio.h ff.h ffconf.h Init.h integer.h PLL.h Storage.h tm4c123gh6pm.h Slave.c
